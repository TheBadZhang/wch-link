# Repository TheBadZhang/wch-link

File readme.md:

# WCH-Link

> # 更推荐使用[uDap](https://github.com/TheBadZhang/uDap)来作为wchlink，因为这个同时兼容了wchlink和DAPLink，使用起来更方便。

简单做了一个ch549的wchlink用于烧录ch32v305制作的dplink，属实是套娃了

## KiCad design wchlink.kicad_pcb

Parts:
C1, C3: 4.7uF; C_0603_1608Metric
C2: 0.1uF; C_0603_1608Metric
C4: 22nF; C_0603_1608Metric
C5, C6: 100nF; C_0603_1608Metric
D1, D2, D3: LED; LED_0603_1608Metric
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_G-Switch_GT-USB-7010ASV
J2: Conn_02x04_Odd_Even; PinHeader_2x04_P2.54mm_Horizontal
R1, R2, R3, R4, R5, R10: 5.1K; R_0603_1608Metric
R6, R7, R8, R9: 270R; R_0603_1608Metric
SW1, SW2: SW_Push; KEY-SMD_4P-L4.2-W3.4-P2.15-LS4.5-TL
U1: CH549G; SOP-16_3.9x9.9mm_P1.27mm
U2: RT9193-33GB; SOT-23-5

Connections:
+3V3: C3.2, C5.1, D3.2 (A), J2.7, R10.1, U1.16 (V33), U2.5 (Vout)
+5V: C1.1, C2.1, D1.2 (A), D2.2 (A), J1.A4 (VBUS_A4), J1.A9 (VBUS_A9), J1.B4 (VBUS_B4), J1.B9 (VBUS_B9), J2.8, U2.1 (Vin), U2.3 (EN)
/CC1: J1.A5 (CC1_A5), R2.1
/CC2: J1.B5 (CC2_B5), R1.1
/CLK: J2.3, R7.2
/DIO: J2.5, R6.2
/D_SWCLK: R7.1, U1.2 (P1.4/SCS/UCC1/AIN4)
/D_SWDIO: R6.1, U1.1 (P1.1/T2EX/CAP2/AIN1)
/LED.CON: R3.2, U1.5 (P1.7/SCK/TXD1_/AIN7)
/LED.RUN: R4.2, U1.4 (P1.6/MISO/RXD1_/VBUS/AIN6)
/MCU.RXD: R8.1, U1.7 (P3.0/RXD)
/MCU.TXD: R9.1, SW2.2, U1.8 (P3.1/TXD)
/RXD: J2.6, R8.2
/TXD: J2.4, R9.2
/USBD+: J1.A6 (D+_A6), J1.B6 (D+_B6), SW1.1, U1.12 (P5.1/DP)
/USBD-: J1.A7 (D-_A7), J1.B7 (D-_B7), U1.13 (P5.0/DM)
GND: C1.2, C2.2, C3.1, C4.2, C5.2, C6.2, J1.A1 (GND_A1), J1.A12 (GND_A12), J1.B1 (GND_B1), J1.B12 (GND_B12), J1.S1 (SHIELD), J1.SH (SHIELD_S1), J2.1, J2.2, R1.2, R2.2, R5.2, SW2.1, U1.14 (GND/VSS), U2.2 (GND)
unnamed: D1.1 (K), R3.1
unnamed: D2.1 (K), R4.1
unnamed: D3.1 (K), R5.1
unnamed: R10.2, SW1.2
unnamed: C4.1, U2.4 (BP)
VDD: C6.1, U1.15 (VDD)

Notes on the sheet:
模式选择
烧录下载

Board: 2 copper layers, 13.0 x 32.5 mm, 25 parts (0 on the bottom side), 23 nets.

## Commit log (part)

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2024-10-16 自制wchlink
2024-10-16 制作还是很简单的
2026-06-16 内嵌了3d模型
2026-06-16 添加了可以在线查看的文档
